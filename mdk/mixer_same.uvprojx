# Keil uVision project mixer_same.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.0.0
  cpu: IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: mixer_same
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  group Source Group 1
    ../source/: main.c watchdog_same70.c adc_same70.c dac_same70.c timer_same70.c board.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
